# Keil uVision project Trabalho_Final.uvprojx, settings and files
target Trabalho_Final (6190000::V6.19::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Trabalho_Final
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6LangP=1 wLevel=1
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c include: C:\ti\TivaWare_C_Series-2.2.0.295;..\Drivers;..\Trabalho_Final
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../Drivers/: UART.c driverleds.c
    ./: main.c
  group Library
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ./: misc.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.0.0
